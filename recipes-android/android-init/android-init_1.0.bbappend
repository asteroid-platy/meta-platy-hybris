FILESEXTRAPATHS_prepend_platy := "${THISDIR}/${PN}:"
