RDEPENDS_${PN}_append_platy = " qt5-qpa-hwcomposer-plugin "
