RDEPENDS_${PN}_append_platy = " ngfd-plugin-droid-vibrator "
