FILESEXTRAPATHS_prepend_platy := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_platy = "platy"
