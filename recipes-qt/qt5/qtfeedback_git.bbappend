RDEPENDS_${PN}_append_platy = "qt5-feedback-haptics-droid-vibrator"
